Commit message: Update new_robot_test.urdf

File: urdf/new_robot_test.urdf (robot description, URDF)
Before this commit: robot mrm, 2 links, 1 joints
Links:
- link base_link: mass None -> 5; geometry collision box size=1 1 1; visual box size=1 1 1
